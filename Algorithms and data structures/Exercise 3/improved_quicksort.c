#include <stdio.h>
#include <stdlib.h>
#include "improved_quicksort.h"

/* кЕИТОУЯЦъА: аКЦЭЯИХЛОР ТАНИМЭЛГСГР ЛЕ ДИАВЫЯИСЛЭ
еъСОДОР: о ПъМАЙАР ПЯОР ТАНИМЭЛГСГ ЙАИ ОИ ДЕъЙТЕР l ЙАИ r ПОУ ДЕъВМОУМ ТО ЙОЛЛэТИ ТОУ ПъМАЙА ПЯОР ТАНИМЭЛГСГ
╦НОДОР: ╦МАР ТАНИМОЛГЛщМОР ПъМАЙАР */
void quicksort(item a[], int l, int r) {
	int i;
	/* ТЕЯЛАТИСЛЭР АМ ТО ЙОЛЛэТИ ПЯОР ТАНИМЭЛГСГ ЕъМАИ ЛИЙЯЭТЕЯО ч ъСО ТОУ M */
	if (r - l <= M) 
		return;
	/* median-of-three ЛщХОДОР */
	exch(a[(l + r) / 2], a[r - 1]);
	compexch(a[l], a[r - 1]);
	compexch(a[l], a[r]);
	compexch(a[r - 1], a[r]);
	/* ДИАЛЕЯИСЛЭР ПъМАЙА */
	i = partition(a, l + 1, r - 1);
	/* АМАДЯОЛИЙч ЙКчСГ ЦИА ТО ПЯЧТО ЙОЛЛэТИ */
	quicksort(a, l, i - 1);
	/* АМАДЯОЛИЙч ЙКчСГ ЦИА ТО ДЕЩТЕЯО ЙОЛЛэТИ */
	quicksort(a, i + 1, r);
}

/* кЕИТОУЯЦъА: бОГХГТИЙч СУМэЯТГСГ ДИАЛщЯИСГР
еъСОДОР: о ПъМАЙАР ПЯОР ТАНИМЭЛГСГ ЙАИ ОИ ДЕъЙТЕР l ЙАИ r ПОУ ДЕъВМОУМ ТО ЙОЛЛэТИ ТОУ ПъМАЙА ПЯОР ДИАЛщЯИСГ
╦НОДОР: ╦МАР ПъМАЙАР ЭПОУ ТА СТОИВЕъА ТО СТОИВЕъО a[r] БЯъСЙЕТАИ СТГМ ТЕКИЙч ТОУ ХщСГ ЛщСА СТОМ ПъМАЙА, ЙАМщМА АПЭ ТА СТОИВЕъА a[1], ., a[r-1] ДЕМ ЕъМАИ ЛЕЦАКЩТЕЯО АПЭ ТО a[r] ЙАИ ЙАМщМА АПЭ ТА СТОИВЕъА a[r+1], ., a[r] ДЕМ ЕъМАИ ЛИЙЯЭТЕЯО АПЭ ТО a[r]
*/
int partition(item a[], int l, int r) {
	int i = l, j = r - 1; /* ДЕъЙТЕР СэЯЫСГР */
	item v = a[r]; /* ДЕъЙТГР ДИАВЫЯИСЛОЩ */
	while (1) { /* АТщЯЛЫМ БЯЭЦВОР */
				/* ЛЕТАЙъМГСГ АЯИСТЕЯОЩ ДЕъЙТГ СэЯЫСГР ЛщВЯИ МА БЯЕХЕъ ЛЕЦАКЩТЕЯО ч ъСО СТОИВЕъО */
		while (less(a[i], v)) i++;
		/* ЛЕТАЙъМГСГ ДЕНИОЩ ДЕъЙТГ СэЯЫСГР ЛщВЯИ МА БЯЕХЕъ ЛИЙЯЭТЕЯО СТОИВЕъО ч МА СУМАМТГХОЩМ ОИ ДЩО ДЕъЙТЕР */
		while (less(v, a[j])) {
			j--;
			if (j == l)
				break;
		}
		/* АМ СУМАМТчХГЙАМ ОИ ДЕъЙТЕР ч О АЯИСТЕЯЭР ПЯОСПщЯАСЕ ТОМ ДЕНИЭ, ТЭТЕ О ПъМАЙАР ЕъМАИ СЕ ТэНГ */
		if (i >= j)
			break;
		/* АМТИЛЕТэХЕСГ СТОИВЕъЫМ */
		exch(a[i], a[j]);
		/* ЙъМГСГ ДЕИЙТЧМ СэЯЫСГР ЙАТэ ЛъА ХщСГ */
		i++;
		j--;
	}
	/* ТОПОХщТГСГ ТОУ СТОИВЕъОУ ДИАВЫЯИСЛОЩ СТГМ СЫСТч ХщСГ */
	exch(a[i], a[r]);
	return i;
}

/* кЕИТОУЯЦъА: аКЦЭЯИХЛОР ТАНИМЭЛГСГР ЛЕ ЕИСАЦЫЦч (АПОДОТИЙч УКОПОъГСГ)
еъСОДОР: о ПъМАЙАР ПЯОР ТАНИМЭЛГСГ ЙАИ ТО ЛщЦЕХОР ТОУ ПъМАЙА
╦НОДОР: ╦МАР ТАНИМОЛГЛщМОР ПъМАЙАР */
void insertionsort_quick(item *a, int n) {
	int i, j;
	item temp;
	/* ЛЕТАЙъМГСГ ТОУ ЛИЙЯЭТЕЯОУ СТОИВЕъОУ СТГМ АЯВч ТОУ ПъМАЙА ЦИА МА ПАъНЕИ ТО ЯЭКО ЖЯОУЯОЩ */
	for (i = 1; i < n; i++) {
		compexch(a[i], a[0]);
	}
	/* ТАНИМЭЛГСГ ЭКЫМ ТЫМ АМТИЙЕИЛщМЫМ */
	for (i = 2; i < n; i++) {
		j = i;
		temp = a[i];
		/* СЩЦЙЯИСГ ТОУ АМТИЙЕИЛщМОУ i ЛЕ ЭКА ТА АМТИЙЕъЛЕМА СТА АЯИСТЕЯэ ТОУ ЛщВЯИ МА БЯЕИ ТО ПЯЧТО ЛЕЦАКЩТЕЯО АМТИЙЕъЛЕМО */
		while (less(temp, a[j - 1])) {
			a[j] = a[j - 1];
			j--;
		}
		a[j] = temp;
	}
}

/* кЕИТОУЯЦъА: сУМэЯТГСГ ТАНИМЭЛГСГР
еъСОДОР: о ПъМАЙАР ЙАИ ТО ЛщЦЕХОР ТОУ ПъМАЙА
╦НОДОР: ╦МАР ТАНИМОЛГЛщМОР ПъМАЙАР */
void sort(item *a, int n) {
	quicksort(a, 0, n - 1);
	insertionsort(a, n);
}

/* кЕИТОУЯЦъА: еЙТЩПЫСГ СТОИВЕъЫМ ПъМАЙА
еъСОДОР: о ПъМАЙАР ЙАИ ТО ЛщЦЕХОР ТОУ ПъМАЙА
╦НОДОР: - */
void display_arr(item *a, int n) {
	int i;
	printf("-----\n");
	for (i = 0; i < n; i++) {
		printf("%d ", a[i]);
	}
	printf("\n-----\n");
}
